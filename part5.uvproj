# Keil uVision project part5.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51RC2 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM (0-0x3FF) CLOCK(40000000) MODP2
  output: younger_I2c +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Directory_Functions_struct.c File_System_v2.c I2C.c I2C_test.c Long_Serial_In.c Play_Song.c print_bytes.c Read_Sector.c SDCard.c SPI.c STA013_config.c UART.c config.asm
